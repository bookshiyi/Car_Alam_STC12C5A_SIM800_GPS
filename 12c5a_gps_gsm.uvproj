# Keil uVision project 12c5a_gps_gsm.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 12c5a_gps_gsm +hex
  c flags: Optimize=7 SizeSpeed=1
  group Source Group 1
    ./: main.c uart1.c uart2.c GPS.c GSM.c devices.c delay.c
